# IAR project MyFirstProject_MSS_CM3_hw_platform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A2F200M3F Actel A2F200M3F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; CMSIS; CMSIS/startup_iar; drivers; drivers/mss_gpio; drivers/mss_hpdma; drivers/mss_nvm; drivers/mss_sys_services; drivers/mss_timer; drivers/mss_uart; drivers_config; drivers_config/sys_config; hal; hal/CortexM3; hal/CortexM3/EWARM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: MyFirstProject_MSS_CM3_hw_platform.out
  ILINK.IlinkIcfFile: CMSIS/startup_iar/smartfusion2_esram_debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: MyFirstProject_MSS_CM3_hw_platform.srec
  ILINK.IlinkIcfFile: CMSIS/startup_iar/smartfusion2_envm.icf
  group CMSIS
    CMSIS/startup_iar/: default_irqs.c low_level_init.c read.c startup_m2sxxx.s vector_table.c write.c
    CMSIS/: system_m2sxxx.c
  group drivers
    drivers/mss_sys_services/: mss_comblk.c mss_sys_services.c
    drivers/mss_gpio/: mss_gpio.c
    drivers/mss_hpdma/: mss_hpdma.c
    drivers/mss_nvm/: mss_nvm.c
    drivers/mss_uart/: mss_uart.c
  group drivers_config
    drivers_config/sys_config/: sys_config.c
  group hal
    hal/CortexM3/: cortex_nvic.c
    hal/CortexM3/EWARM/: hal.s hw_reg_access.s
  group Headers
    hal/CortexM3/: cortex_nvic.h
    hal/CortexM3/EWARM/: cpu_types.h hw_macros.h
    hal/: hal.h hal_assert.h hw_reg_access.h
    CMSIS/: hw_reg_io.h m2sxxx.h mss_assert.h sys_init_cfg_types.h system_m2sxxx.h
    drivers/mss_sys_services/: mss_comblk.h mss_comblk_page_handler.h mss_sys_services.h
    drivers/mss_gpio/: mss_gpio.h
    drivers/mss_hpdma/: mss_hpdma.h
    drivers/mss_nvm/: mss_nvm.h
    drivers/mss_timer/: mss_timer.h
    drivers/mss_uart/: mss_uart.h mss_uart_regs.h
    ./: MyFirstProject_hw_platform.h
    drivers_config/sys_config/: sys_config.h sys_config_mss_clocks.h

# IAR project MyFirstProject_MSS_CM3_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; CMSIS; CMSIS/startup_iar; drivers; drivers/mss_gpio; drivers/mss_hpdma; drivers/mss_nvm; drivers/mss_sys_services; drivers/mss_timer; drivers/mss_uart; drivers_config; drivers_config/sys_config; hal; hal/CortexM3; hal/CortexM3/EWARM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: user1.out
  ILINK.IlinkIcfFile: CMSIS/startup_iar/smartfusion2_esram_debug.icf
  ILINK.IlinkAdditionalLibs: Debug/Exe/MyFirstProject_MSS_CM3_hw_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: CMSIS/startup_iar/smartfusion2_envm.icf
  ILINK.IlinkAdditionalLibs: Release/Exe/MyFirstProject_MSS_CM3_hw_platform.a
  group (top)
    ./: main.c

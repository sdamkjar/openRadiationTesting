<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/MyFirstProject_MSS_CM3_hw_platform.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MyFirstProject_MSS_CM3_app.ewp</path>
  </project>

  <batchBuild/>
</workspace>


